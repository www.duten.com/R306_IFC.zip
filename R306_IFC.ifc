Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: Project Number
Time: 2023-03-01T11:02:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20211019_1515(x64) - Exporter 20.2.60.15 - Alternate UI 20.2.60.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 01 11:02:38 2023 * Host: DESKTOP-KN3O7NT * Database: C:\Users\SARAHS~1\AppData\Local\Temp\042f798a-930f-4b1e-b064-69f42bce4e49\1a5905a5-6bba-4c73-af11-f848f0998351\ifc * Database version: 5507 * Database creation date: Wed Mar 01 11:02:37 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 01 11:02:37 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 01 11:02:37 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Awaiting Approval

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuilding, n/a
LongName: n/a
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 0
